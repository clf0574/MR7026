# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: clf +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8001800 size 0xe400
  memory RVCT5: ROM 0x800fc00 size 0x8
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../../User/: main.c App_IT1.c Func.c App_Wireless.c my_queue_chl.c Time_Triggered.c Time_Triggered.h Addr_eeprom.h includes.h AcAlg.c ac.lib
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f10x_it.c stm32f10x_assert.c bsp_msg.c
    ../../User/bsp/src/: bsp_key.c bsp_timer.c bsp_eeprom.c bsp_led.C bsp_usart.c bsp_iwdg.c bsp_CC1101.c bsp_A7139.C bsp_DS28E11.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_iwdg.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.开发环境说明.txt
